# Keil uVision project ugfx_virtual_keyboard.uvprojx, settings and files
target STM32F746 Flash (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: ugfx_virtual_keyboard +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\ugfx_virtual_keyboard;..\ugfx;..\ugfx\drivers\gdisp\STM32LTDC;..\ugfx\drivers\ginput\touch\FT5336;..\ugfx\boards\base\STM32F746-Discovery
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source
    ./: main.c gfxconf.h gui.c
  group ugfx
    ../ugfx/src/: gfx_mk.c
    ../ugfx/drivers/gdisp/STM32LTDC/: gdisp_lld_STM32LTDC.c
    ../ugfx/drivers/ginput/touch/FT5336/: gmouse_lld_FT5336.c
    ../ugfx/boards/base/STM32F746-Discovery/: stm32f7_i2c.c
    ../ugfx/src/gwin/: gwin_keyboard.c
software components: CMSIS:CORE 4.2.0, CMSIS:RTOS:Keil RTX 4.79.0, Board Support:Drivers:SDRAM 1.0.0, Board Support:LED 1.0.0, Device:STM32Cube Framework:Classic 1.0.0, Device:STM32Cube HAL:Common 1.0.1, Device:STM32Cube HAL:Cortex 1.0.1, Device:STM32Cube HAL:DMA 1.0.1, Device:STM32Cube HAL:DMA2D 1.0.1, Device:STM32Cube HAL:GPIO 1.0.1, Device:STM32Cube HAL:LTDC 1.0.1, Device:STM32Cube HAL:PWR 1.0.1, Device:STM32Cube HAL:RCC 1.0.1, Device:STM32Cube HAL:SDRAM 1.0.1, Device:Startup 1.0.1
