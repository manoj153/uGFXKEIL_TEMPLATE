# Keil uVision project KEILPROJECT2.uvprojx, settings and files
target KEILPROJECT2 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.9.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x00200000-0x2FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: KEILPROJECT2
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c misc: --C99
  c include: ../Inc;  ../Drivers/STM32F7xx_HAL_Driver/Inc;  ../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;  ../Middlewares/Third_Party/FatFs/src/drivers;  ../Drivers/CMSIS/Device/ST/STM32F7xx/Include;  ../Middlewares/Third_Party/FatFs/src;  ../Drivers/CMSIS/Include;  ..\ugfx_pr;  ..\ugfx;  ..\ugfx\boards\base\STM32F746-Discovery;  ..\ugfx\src\gdisp\mcufont;  ..\GUI\output;  ..\ugfx\drivers\gdisp\STM32LTDC;  ..\User;  ..\GUI\output\rsc
  library: MicroLIB
  memory RVCT4: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f7xx_it.c fatfs.c main.c stm32f7xx_hal_msp.c bsp_driver_sdram.c
  group ugfx
    ../ugfx/drivers/gdisp/STM32LTDC/: gdisp_lld_STM32LTDC.c
    ../ugfx/src/: gfx_mk.c
    ../ugfx/boards/base/STM32F746-Discovery/: stm32f746g_discovery_sdram.c stm32f746g_raw32_ugfx.c stm32f7_i2c.c
    ../ugfx/drivers/ginput/touch/FT5336/: gmouse_lld_FT5336.c
    ../GUI/output/: gui.c
    ../ugfx_pr/: gfxconf.h
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_dsi.c stm32f7xx_hal_rtc.c stm32f7xx_hal_dma.c stm32f7xx_hal_gpio.c stm32f7xx_hal_spi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_i2c.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal.c stm32f7xx_hal_spdifrx.c stm32f7xx_hal_uart.c stm32f7xx_hal_sd.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_adc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_tim.c stm32f7xx_hal_pwr_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_adc.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_qspi.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sdram_diskio.c
software components: CMSIS:CORE 4.1.0
